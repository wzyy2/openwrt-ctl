# Keil uVision project LED.uvproj, settings and files
target STM32F407 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F407 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\CMSIS;..\User;..\Libraries\inc;..\Libraries\src;..\MyLibaries;..\JPG;..\APP;..\BSP;..\DEV
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group APP
    ../APP/: application.c filter.c pid.c visual scope.c uart_state.c
  group DEV
    ../DEV/: 24l01.c dcmi_ov7620.c key.c lcd.c 5110.c
  group BSP
    ../BSP/: adc.c bsp.c counter.c MyFunction.c System_Config.c Usart_config.c MotorCtl.c
  group HEADER
    ../DEV/: 24l01.h 5110.h dcmi_ov7620.h key.h lcd.h
    ../BSP/: adc.h bsp.h counter.h MotorCtl.h MyF4Config.h
    ../APP/: application.h filter.h font.h pid.h visual scope.h
  group Startup
    ../CMSIS/Startup/: startup_stm32f4xx.s
  group Libraries
    ../Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
